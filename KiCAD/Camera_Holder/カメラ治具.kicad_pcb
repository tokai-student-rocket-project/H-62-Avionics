# Repository tokai-student-rocket-project/H-62-Avionics

## KiCad design KiCAD/Camera_Holder/カメラ治具.kicad_pcb

Parts:
H1, H2: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
R1: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal

Connections:
+12V: H1.1, R1.1
GND: H2.1, R1.2

Board: 2 copper layers, 139.6 x 65.0 mm, 3 parts (0 on the bottom side), 2 nets.

## KiCad design KiCAD/FeRAMTestBoard/FeRAMTestBoard.kicad_pcb

Parts:
C1: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1, J2: Conn_01x08; PinHeader_1x08_P2.54mm_Vertical
R1: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: MB85RQ8MX; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
SCK: J2.8, U1.16 (SCK)
SI(IO0): J2.7, U1.15 (SI(IO0))
SO(IO1): J1.8, U1.8 (SO(IO1))
VDD: C1.2, J1.2, R1.1, U1.2 (VDD)
VSS: C1.1, J2.2, U1.10 (VSS)
~CS: J1.7, R1.2, U1.7 (~CS)
~HOLD(IO3): J1.1, U1.1 (~HOLD(IO3))
~WP(IO2): J2.1, U1.9 (~WP(IO2))

Notes on the sheet:
コネクタ右
FeRAM
コネクタ左

Board: 2 copper layers, 21.3 x 21.3 mm, 5 parts (0 on the bottom side), 8 nets.

File KiCAD/FeRAMTestBoard/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,0603,1,0.1uF,
"J1, J2",PinHeader_1x08_P2.54mm_Vertical,2,Conn_01x08,
R1,0603,1,4.7kR,
U1,SOIC-16W_7.5x10.3mm_P1.27mm,1,MB85RQ8MX,

## KiCad design KiCAD/MKRGPSShield/MKRGPSShield_V4.0.kicad_pcb

Parts:
BATT0: BATT-HOLDER_12MM
C1, C2: 1u; 0402-1005X55N; VOLTAGE 25V
C3: 100n; 0402-1005X55N
C4: 100n; 0402-1005X55N; VOLTAGE 25V
D1, D2: SDM40E20LC-7; SOT65P210X110-3N
FD1, FD2, FD3: DNP; FD-1-1.5
FRAME1: DNP; FRAME
IC1: SAM-M8Q; UBLOXLIB_SAM-M8Q
J1, J2: -; 1X14_SMD_TH
J3: -; SM05B-SRSS-TB
PPS0: DNP; LEDC1608X80N-AK
R1, R2: DNP; 0402-1005X55N
R4: 100k; 0402-1005X55N; MPN RC0402FR-07100KL
SJ1, SJ2, SJ5, SJ6, SJ7, SJ8: DNP; SJ
U2: AP2112K-3.3; SOT25

Connections:
+3V3: D1.1 (A1), D2.2 (A2), J2.12
+5V: C1.1, J3.1, U2.1 (IN), U2.3 (EN)
EXTINT: IC1.19 (EXTINT), J2.2, J3.2, SJ1.1, SJ1.2
GND: BATT0.P$1 (-), C1.2, C2.2, C3.2, C4.2, IC1.1 (GND), IC1.4 (GND), IC1.5 (GND), IC1.6 (GND), IC1.10 (GND), IC1.11 (GND), IC1.15 (GND), IC1.16 (GND), IC1.20 (GND), J2.11, J3.5, J3.SH1 (SH), J3.SH2 (SH), PPS0.C, U2.2 (GND/ADJ)
unnamed: J2.1, SJ2.1
unnamed: D2.3 (K), R2.2
unnamed: J2.10, SJ7.1
unnamed: J2.3, SJ8.1
unnamed: PPS0.A, R1.2
unnamed: C2.1, D1.2 (A2), U2.5 (OUT)
RESET_N: IC1.18 (RESET_N), SJ7.2
RXD: IC1.14 (RXD), J2.9, R4.1, SJ6.1, SJ6.2
SAFEBOOT_N: IC1.8 (SAFEBOOT_N), SJ8.2
SCL: IC1.12 (SCL), J3.3
SDA: IC1.9 (SDA), J3.4
TP: IC1.7 (TP), R1.1, SJ2.2
TXD: IC1.13 (TXD), J2.8, SJ5.1, SJ5.2
VBCKP: BATT0.P$2 (+), C4.1, IC1.3 (V_BCKP), R2.1
VCC: C3.1, D1.3 (K), IC1.2 (VCC_IO), IC1.17 (VCC), R4.2

Notes on the sheet:
Main Supply
Arturo Guadalupi
MKR Shield Header
Backup Supply
Wire Sensor Connector
GNSS/GPS Receiver Antenna

Board: 2 copper layers, 45.7 x 25.0 mm, 34 parts (6 on the bottom side), 19 nets.

Other parts of the board:
U$5, U$6, U$7, U$8: MH_RND_F_2.2MM_NM
UNK_HOLE_0: dummyfp0
UNK_HOLE_1: dummyfp1
UNK_HOLE_2: dummyfp2
UNK_HOLE_3: dummyfp3

## KiCad design KiCAD/PowerModule/PowerModule.kicad_pcb

Parts:
C1, C2, C3, C4, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C5: 33uF; CP_Elec_6.3x5.9
C7: 0.1uF; C_0603_1608Metric
D1, D2, D3: Orange; LED_0603_1608Metric
D4: SR54F; D_SMB_Handsoldering
H1, H2, H3: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
H4: MountingHole_Pad; MountingHole_3.2mm_M3_ISO7380_Pad_TopBottom
J2, J3, J4, J6: DF1B-2S-2.5R
J5, J7: DF11-8DP-2DS
J8: DF51-2P-2DS
Q1, Q2: AO3401A; SOT-23
R1, R3, R4, R6, R14, R15: 10R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R5, R16: 0.1R; R_2816_7142Metric_Pad3.20x4.45mm_HandSolder
R7, R9, R10: 2.4kR; R_0603_1608Metric
R8: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11, R12: 5.6kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 3.3kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TH1: 10kR; PinHeader_1x02_P1.00mm_Vertical
U1, U2, U4: INA219BxDCN; SOT-23-8
U3: StrawberryLinux_LTC3118

Connections:
+3.3V: C1.2, C3.2, C6.2, J7.1, R8.1, U1.4 (VS), U2.4 (VS), U2.7 (A0), U4.4 (VS), U4.7 (A0), U4.8 (A1)
+12V: J5.1, J5.2, R7.2, R9.2, R10.2, R15.1, R16.2
/BAT IN: J3.2, R4.2, R5.1
/BAT OUT: R5.2, R6.2, U3.2 (VIN2), U3.7 (RUN2)
/BUS IN: Q2.3 (S), R14.2, R16.1
/GPU IN: J8.2, R1.2, R2.1
/GPU OUT: R2.2, R3.2, U3.3 (VIN1), U3.6 (RUN1)
/VOUT: C5.1, D4.1 (K), Q1.3 (S), R11.2, R12.1, U3.14 (VOUT), U3.15 (VOUT)
GND: C1.1, C3.1, C6.1, H1.1, H2.1, H3.1, H4.1, J2.1, J4.1, J5.3, J5.4, J6.1, J7.2, J8.1, TH1.2, U1.3 (GND), U1.7 (A0), U1.8 (A1), U2.3 (GND), U2.8 (A1), U3.1 (GND), U3.4 (GND), U3.5 (GND), U3.16 (GND), U3.17 (GND), U4.3 (GND)
I2C_SCL: J7.4, U1.5 (SCL), U2.5 (SCL), U4.5 (SCL)
I2C_SDA: J7.3, U1.6 (SDA), U2.6 (SDA), U4.6 (SDA)
unnamed: D1.2 (A), R7.1
unnamed: D1.1 (K), U3.13 (V1GD)
unnamed: D2.2 (A), R9.1
unnamed: D2.1 (K), U3.12 (V2GD)
unnamed: D3.2 (A), R10.1
unnamed: D3.1 (K), U3.11 (PGD)
unnamed: D4.2 (A), J4.2, R11.1
unnamed: J2.2, J3.1
unnamed: J5.5, J5.6
unnamed: J5.7, J5.8
unnamed: J6.2, R13.2
unnamed: Q1.2 (D), Q2.2 (D)
unnamed: C5.2, Q1.1 (G), Q2.1 (G), R12.2, R13.1
unnamed: C2.1, R1.1, U1.1 (IN+)
unnamed: C2.2, R3.1, U1.2 (IN-)
unnamed: C4.1, R4.1, U2.1 (IN+)
unnamed: C4.2, R6.1, U2.2 (IN-)
unnamed: U3.8 (VCC), U3.9 (MODE), U3.10 (SEL)
unnamed: C7.1, R14.1, U4.1 (IN+)
unnamed: C7.2, R15.2, U4.2 (IN-)
VREF_T1: J7.5, R8.2, TH1.1
VREF_T2: J7.6
VREF_T3: J7.7
VREF_T4: J7.8

Notes on the sheet:
From Ground Power Unit (External)
A0とA1はスレーブアドレス を設定するためのピン
BUS
Slave Address : 10000000
Batery Switch (Connector)
Battery Moduleに接続
MONITOR
Battery Module の Capacitor に接続
電力モニタ

Board: 2 copper layers, 90.0 x 70.0 mm, 45 parts (0 on the bottom side), 32 nets.

File KiCAD/PowerModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C3, C4, C6, C7",0603,6,0.1uF,
C5,CP_Elec_6.3x5.9,1,33uF,
"D1, D2, D3",0603,3,Orange,
D4,D_SMB_Handsoldering,1,SR54F,
"J2, J3, J4, J6",DF1B-2S-2.5R,4,DF1B-2S-2.5R,
"J5, J7",DF11-8DP-2DS,2,DF11-8DP-2DS,
J8,DF51-2P-2DS,1,DF51-2P-2DS,
"Q1, Q2",SOT-23,2,AO3401A,
"R1, R14, R15, R3, R4, R6",0603,6,10R,
"R10, R7, R9",0603,3,2.4kR,
R11,0603,1,5.6kR,
R12,0603,1,5.6kR,
R13,0603,1,3.3kR,
"R16, R2, R5",2816,3,0.1R,
R8,0603,1,100kR,
TH1,PinHeader_1x02_P1.00mm_Vertical,1,10kR,
"U1, U2, U4",SOT-23-8,3,INA219BxDCN,
U3,StrawberryLinux_LTC3118,1,~,

## KiCad design KiCAD/SensingModule/SensingModule/SensingModule.kicad_pcb

Board: 2 copper layers, 90.0 x 70.0 mm, 39 parts (31 on the bottom side), 25 nets, no tracks yet.

Parts:
C1: 10uF; C_1206_3216Metric_Pad1.33x1.80mm_HandSolder
C2: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4, C5, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2, D5, D6: B; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: R; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: GS1010FL; D_SOD-123F
J3: TERMISTOR; DF51-2P-2DS
R1, R2, R12, R13: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R6, R7, R8, R9: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14, R15: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: Arduino MKR WAN 1310; BOARD_ARDUINO_MKR_WAN_1310
U2: NJM7805SDL1; TO-252-2
U3: MCP2562-E-P; DIP-8_W7.62mm
U4: MCP2515-I/P; DIP-18_W7.62mm
U5, U6, U7, U8: MB85RS2MT; DIP-8_W7.62mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3V: C5.2, C6.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R14.1, R15.1, U3.5 (Vio), U4.18 (VDD), U5.3 (~WP), U5.7 (~HOLD), U5.8 (VDD), U6.3 (~WP), U6.7 (~HOLD), U6.8 (VDD), U7.3 (~WP), U7.7 (~HOLD), U7.8 (VDD), U8.3 (~WP), U8.7 (~HOLD), U8.8 (VDD)
+5V: C2.1, C3.1, C4.2, D4.2 (A), U2.3 (OUT), U3.3 (VDD)
+12V: C1.1, D4.1 (K), R10.1, U2.1 (IN)
CAN_H: R11.1, U3.7 (CANH)
CAN_L: R11.2, U3.6 (CANL)
CAN_RX: U3.4 (RXD), U4.2 (RXCAN)
CAN_TX: U3.1 (TXD), U4.1 (TXCAN)
GND: C1.2, C2.2, C3.2, C4.1, C5.1, C6.1, C7.2, C8.2, D1.1 (K), D2.1 (K), D3.1 (K), D5.1 (K), D6.1 (K), J3.1, U2.2 (GND), U3.2 (VSS), U3.8 (STBY), U4.9 (VSS), U5.4 (GND), U6.4 (GND), U7.4 (GND), U8.4 (GND)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R10.2
unnamed: D5.2 (A), R12.2
unnamed: D6.2 (A), R13.2
unnamed: R14.2, U4.17 (~RESET)
OSC1: C7.1, U4.8 (OSC1), Y1.2
OSC2: C8.1, U4.7 (OSC2), Y1.1
SPI_CS_FRAM0: R6.1, U5.1 (~CS)
SPI_CS_FRAM1: R5.1, U6.1 (~CS)
SPI_CS_FRAM2: R4.1, U7.1 (~CS)
SPI_CS_FRAM3: R3.1, U8.1 (~CS)
SPI_CS_MCP: R9.1, U4.16 (~CS)
SPI_MISO: U4.15 (SO), U5.2 (SO), U6.2 (SO), U7.2 (SO), U8.2 (SO)
SPI_MOSI: U4.14 (SI), U5.5 (SI), U6.5 (SI), U7.5 (SI), U8.5 (SI)
SPI_SCLK: U4.13 (SCK), U5.6 (SCK), U6.6 (SCK), U7.6 (SCK), U8.6 (SCK)
VREF_THERMISTOR: J3.2, R15.2

File KiCAD/SensingModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_Elec_10x10,1,330uF,
"C4, C5, C6",0603,3,0.1uF,
"C7, C8",0603,2,15pF,
"D1, D2, D5, D6",0603,4,B,
D3,0603,1,Green,
D4,D_SOD-123F,1,GS1010FL,
J1,DF11-8DP-2DS,1,BUS,
J2,DF11-8DP-2DS,1,MONITOR,
J3,DF51-2P-2DS,1,DF51-2P-2DS,
PS1,M78AR03305,1,M78AR05-0.5,
"R1, R12, R13, R2",0603,4,680R,
R10,0603,1,2.2kR,
R11,0603,1,120R,
"R14, R15",0603,2,10kR,
"R16, R5, R6, R7, R8, R9",0603,6,4.7kR,
U1,BOARD_ARDUINO_MKR_WAN_1310,1,ARDUINO_MKR_WAN_1310,
"U12, U13, U14",SOIC-16W_7.5x10.3mm_P1.27mm,3,~,
U2,AE-BNO055-BO,1,~,
U3,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2562-E-P,
U4,SOIC-18W_7.5x11.6mm_P1.27mm,1,MCP2515-I/P,MCP2515-I/P
Y1,Crystal_SMD_HC49-SD,1,8MHz,
