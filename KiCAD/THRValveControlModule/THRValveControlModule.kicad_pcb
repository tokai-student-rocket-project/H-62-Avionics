# Repository tokai-student-rocket-project/H-62-Avionics (continued)

## KiCad design KiCAD/SensingModule/SensingModule.kicad_pcb (continued)

Parts:
C4, C5, C6: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C7, C8: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D5, D6: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
R11: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U4: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U9: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3.3VP: C5.2, C6.2, R14.2, U4.20 (VDD), U9.5 (Vio); also elsewhere on the board
+5V: C4.2, U9.3 (VDD); also elsewhere on the board
CAN_H: R11.1, U9.7 (CANH); also elsewhere on the board
CAN_L: R11.2, U9.6 (CANL); also elsewhere on the board
CAN_RECEIVE_STATUS: R12.1; also elsewhere on the board
CAN_RX: U4.2 (RXCAN), U9.4 (RXD)
CAN_SEND_STATUS: R13.1; also elsewhere on the board
CAN_TX: U4.1 (TXCAN), U9.1 (TXD)
GND: C4.1, C5.1, C6.1, C7.2, C8.2, D5.1 (K), D6.1 (K), U4.10 (VSS), U9.2 (VSS), U9.8 (STBY); also elsewhere on the board
unnamed: D5.2 (A), R12.2
unnamed: D6.2 (A), R13.2
unnamed: R14.1, U4.19 (~RESET)
OSC1: C7.1, U4.9 (OSC1), Y1.2
OSC2: C8.1, U4.8 (OSC2), Y1.1
SPI_CS_MCP: U4.18 (~CS); also elsewhere on the board
SPI_MISO: U4.17 (SO); also elsewhere on the board
SPI_MOSI: U4.16 (SI); also elsewhere on the board
SPI_SCLK: U4.14 (SCK); also elsewhere on the board

Notes on the sheet:
CAN Status
CAN トランシーバー
CAN コントローラー

Parts:
C1: 330uF; CP_Elec_10x10
C10, C11: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D3: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D7: SS2040FL; D_SOD-123F
PS1: M78AR05-0.5; M78AR03305; Manufacturer_Part_Number M78AR05-0.5
R10: 2.2kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U8: RT9080-33GJ5; TSOT-23-5

Connections:
+3.3VP: C11.1, U8.5 (OUT); also elsewhere on the board
+5V: C10.1, PS1.3 (+VOUT), U8.1 (IN), U8.3 (EN); also elsewhere on the board
+12V: C1.1, D7.2 (A), R10.1; also elsewhere on the board
GND: C1.2, C10.2, C11.2, D3.1 (K), PS1.2 (GND), U8.2 (GND); also elsewhere on the board
unnamed: D3.2 (A), R10.2
unnamed: D7.1 (K), PS1.1 (+VIN)

Notes on the sheet:
本当は RT9080-33GJ5
逆接続保護ダイオード
12V Status
From BUS
To MCU
Switching Regulator
Linear Regulator
From DCDC

Parts:
C14, C15, C16: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J3: DF51-2P-2DS
J4: DF51A-4P-2DS
R15: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U2: BNO055; AE-BNO055-BO
U5, U6, U7: MB85RQ8MX; SOIC-16W_7.5x10.3mm_P1.27mm
U14: SOIC-16W_7.5x10.3mm_P1.27mm; not fitted

Connections:
+3.3V: C14.1, C15.1, C16.1, J4.2, R15.1, U2.1 (VIN), U5.1 (~HOLD(IO3)), U5.2 (VDD), U5.9 (~WP(IO2)), U6.1 (~HOLD(IO3)), U6.2 (VDD), U6.9 (~WP(IO2)), U7.1 (~HOLD(IO3)), U7.2 (VDD), U7.9 (~WP(IO2)), U14.8 (WP(IO2)), U14.9 (HOLD(IO3)), U14.10 (VDD); also elsewhere on the board
GND: C14.2, C15.2, C16.2, J3.1, J4.1, U2.2 (GND), U2.7 (GND), U5.10 (VSS), U6.10 (VSS), U7.10 (VSS), U14.7 (VSS); also elsewhere on the board
I2C_SCL: J4.4, U2.4 (SCL/R); also elsewhere on the board
I2C_SDA: J4.3, U2.3 (SDA/T); also elsewhere on the board
SPI_MISO: U5.8 (SO(IO1)), U6.8 (SO(IO1)), U7.8 (SO(IO1)), U14.16 (SO(IO1)); also elsewhere on the board
SPI_MOSI: U5.15 (SI(IO0)), U6.15 (SI(IO0)), U7.15 (SI(IO0)), U14.2 (SI(IO0)); also elsewhere on the board
SPI_SCLK: U5.16 (SCK), U6.16 (SCK), U7.16 (SCK), U14.1 (SCK); also elsewhere on the board
SPI_~CS_FeRAM0: U5.7 (~CS); also elsewhere on the board
SPI_~CS_FeRAM1: U6.7 (~CS); also elsewhere on the board
SPI_~CS_FeRAM2: U7.7 (~CS); also elsewhere on the board
VREF_THERMISTOR: J3.2, R15.2; also elsewhere on the board

Notes on the sheet:
THERMISTOR
LPS28DFW
FeRAM1
BNO055
FeRAM2
FeRAM0
Thermistor

Board: 2 copper layers, 90.0 x 70.0 mm, 48 parts (23 on the bottom side), 32 nets.

File KiCAD/SensingModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_Elec_10x10,1,330uF,
"C10, C11",0805,2,1uF,
"C14, C15, C16, C4, C5, C6",0603,6,0.1uF,
"C7, C8",0603,2,15pF,
"D1, D2, D5, D6",0603,4,Blue,
D3,0603,1,Green,
D7,D_SOD-123F,1,SS2040FL,
"H5, H6, H7, H8",MountingHole_3.2mm_M3_DIN965_Pad_TopBottom,4,MountingHole_Pad,
J1,DF11-8DP-2DS,1,DF11-8DP-2DS,
J3,DF51-2P-2DS,1,DF51-2P-2DS,
J4,DF51A-4P-2DS,1,DF51A-4P-2DS,
PS1,M78AR03305,1,M78AR05-0.5,
"R1, R12, R13, R2",0603,4,680R,
R10,0603,1,2.2kR,
R11,0603,1,120R,
"R14, R15",0603,2,10kR,
"R17, R5, R6, R7, R8, R9",0603,6,4.7kR,
U1,BOARD_ARDUINO_MKR_WAN_1310,1,ARDUINO_MKR_WAN_1310,
U2,AE-BNO055-BO,1,BNO055,
U4,TSSOP-20_4.4x6.5mm_P0.65mm,1,MCP2515-xST,
"U5, U6, U7",SOIC-16W_7.5x10.3mm_P1.27mm,3,MB85RQ8MX,
U8,TSOT-23-5,1,RT9080-33GJ5,
U9,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2562-E-SN,
Y1,Crystal_HC49-4H_Vertical,1,8MHz,

## Commit log (part)

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2025-04-30 README を更新
2025-04-30 Sensingの配線作業終わり、確認お願いします。
2025-04-30 PDR資料を追加
2025-04-30 必要ないので削除
2025-04-30 READMEを更新
2025-04-30 電源，RS485の仕様を確定
2025-05-01 基本的な機能が完成
2025-05-01 B3Mの動作確認完了
2025-05-02 GNDが繋がらない件です。確認お願いします
2025-05-02 BatteryModuleの外形完成
2025-05-02 GPSShieldの部分完了
2025-05-04 CANトランシーバーの配線完了
2025-05-04 CANコントローラーの回路図完成
2025-05-04 バスの回路図完成，LEDの配置を変更
2025-05-04 分離周りの回路図完成
2025-05-04 M85RQ8MX の回路図完成
2025-05-04 DCDCコンバーターを交換，3.3Vレギュレーターを配置
2025-05-04 GNSSモジュール，SAM-M8Qの回路図完成
2025-05-04 回路図8割完成
2025-05-04 配線8割り終わり．次の作業....
2025-05-04 データシートをいろいろ追加
2025-05-04 ステータスLEDの表示まで完了
2025-05-05 後は最終確認
2025-05-05 残りは最終確認
2025-05-05 エラー０！！
2025-05-05 CDR資料を追加
2025-05-05 データシートを追加
2025-05-05 名称を変更
2025-05-05 dxfを追加．KiCADにインポートすれば基板外形を作成できる．
2025-05-05 現状の画像を追加
2025-05-05 FeRAMを3個に増設
2025-05-05 値渡しに変更
2025-05-05 RP2040の環境を構築．増やす場合はコピペすればOK
2025-05-07 Seeed RP2040 での動作確認完了
2025-05-07 型を変更
2025-05-08 配線完了
2025-05-08 配線確認お願いします
2025-05-08 簡単な警告を修正
2025-05-08 塗りつぶしとクリアランスの設定を変更．エラーは無し．
2025-05-08 電源部に保護を追加．DRCエラー無し．
2025-05-08 BNO055のシンボルを変更．
2025-05-09 Sensing Build-1完成
2025-05-09 Power Build-1,Battery Build-1完成
2025-05-10 最終確認終わり
2025-05-10 取付穴位置を変更
2025-05-10 取付穴位置を変更．キャパシターをSubaru Plateへ移動
2025-05-10 試しにガーバーを出力した
2025-05-10 取り付け穴位置を更新
2025-05-11 3Dモデルを組み合わせて結合試験する．
2025-05-11 3Dモデルを組み合わせて結合試験する
2025-05-11 ガバーデータ生成
2025-05-20 ライブラリを多数追加
2025-05-20 ValveControlModuleの開発開始
2025-05-20 環境を構築
2025-05-21 FeRAM動作はしているみたい
2025-05-21 フォルダを整理
2025-05-21 ログダンパーを作成
2025-05-21 フライト用の場所を作成
2025-05-21 MB85RQ8MXにて書き込みと読み出しできた
2025-05-21 lps28dfwで取得したデータ
2025-05-24 ライブラリを追加
2025-05-24 FeRAM3つ用のライブラリを作成
2025-05-24 高度計のライブラリを作成中
2025-05-24 ValveControlModule用のログダンパーを追加
2025-05-24 FlightModule用のログダンパーを追加
2025-05-26 dump中はステータスLEDがON
2025-05-26 FeRAMのテストコードを追加
2025-05-26 FeRAMのテスト用ログダンパーを追加
2025-05-26 テストしたデータを追加
2025-05-26 サーボモーター，アンビリカル信号の動作確認
2025-05-26 高度周りの作業中
2025-05-26 仕様率などをコメントアウト
2025-05-26 ENピンを変更
2025-05-26 型を変更．65535以上を表現可能に．
2025-05-26 SHUTDOWNまでロギングできるように改良
2025-05-26 テストデータを更新
2025-05-29 HIGH, LOW を反転
2025-05-29 コメントアウト
2025-05-29 ライブラリを改良
2025-05-31 バルブ用の識別子を追加
2025-05-31 M5Stampでの開発を想定して追加
2025-05-31 成形しただけ
2025-05-31 ロギングするデータを増やした
2025-05-31 2つのサーボモーターのデータをロギングできるようにした
2025-05-31 サーボモーターのデータはフライトモジュールに送信する仕様に変更（一時的）
2025-05-31 ログをダンプできないのでいろいろ調査
2025-05-31 新たな環境を設定
2025-06-01 Sensing Module 関係の開発を開始
2025-06-01 Flight Moduleのロギング検証結果を追加
2025-06-01 サーミスターのライブラリを追加
2025-06-01 FeRAMの動作確認できないので単体テストを実施する方向で
2025-06-01 Flight Module のビルド2が完成
2025-06-02 電源関係を結局作ることにした
2025-06-05 ランチャー周りに設置する物を追加
2025-06-05 1段分離のブロックダイアグラムを追加
2025-06-05 バルブ周りのブロック図を追加
2025-06-05 電源系のブロックを追加
2025-06-05 2段分離のブロック図を追加
2025-06-05 MCP1792のブロック図を追加
2025-06-05 MCP2562のデータシートを追加
2025-06-05 環境をコメントアウトで選択できるように
2025-06-05 PowerControlModuleを作成．ソフトウェアの開発も進めなければいけない....
2025-06-05 きれいに配線できるようになった．
2025-06-05 Build-2完成．今回は発注しない．
2025-06-05 PowerModule，Build-2完成．発注．
2025-06-05 Build-2完成．発注．
2025-06-09 Build-3完成．本日発注．
2025-06-09 INA228のデータシートを追加
2025-06-09 安全審査書用の図
2025-06-11 CF試験用の簡易コードを作成
2025-06-12 FeRAM用のテストボードを追加
2025-06-12 Build-3発注した
2025-06-12 BatteryModule，Build-2完成．今日発注
2025-06-12 リン酸鉄リチウムイオンバッテリー充電池のデータシートを追加
2025-06-12 18650バッテリーホルダーのデータシートを追加
2025-06-12 AO3400Aのデータシートを追加
2025-06-12 AO3401のデータシートを追加
2025-06-12 LiFePO4バッテリーのデータシートを追加
2025-06-12 GNSSの受信前準備
2025-06-12 LTspiceで試した回路を追加
2025-06-18 環境構築
2025-06-18 18650用のバッテリーモジュールを作成
2025-06-18 燃焼実験を経て双方のバルブの角度を変更
2025-06-18 圧力センサー、FeRAMの動作確認
2025-06-18 ロードスイッチの動作を確認．なお，ボード図は間違っている．
2025-06-18 18650, LiFePO4のデータシートを追加
2025-06-18 電源系統図を修正
2025-06-19 キャリブレーション周りを書いてる．
2025-06-19 再度修正
2025-06-21 ダウンリンクの環境を構築
2025-06-21 地上局の環境を構築
2025-06-21 いったんコミット
2025-06-21 MOSFETのフットプリントを修正
2025-06-21 MOSFET周りのフットプリント，回路図を修正
2025-06-22 Build-4作成完了
2025-06-24 Build-1発注済み
2025-06-24 Build-2発注済み
2025-06-24 Build-4発注済み
2025-06-24 Build-3発注済み
2025-06-25 カメラ治具関連のファイルをアップロード
2025-06-25 STEPファイルを作成
2025-06-25 STEPファイルを出力
2025-07-02 PowerModuleの開発開始
2025-07-05 ライブラリを作成
2025-07-05 ENピンの動作を確認
2025-07-05 CAN 通信確認
2025-07-05 PowerMonitorに対応
2025-07-05 サーボモータの電源イネーブル機能を作成
2025-07-05 PowerMonitorの機能を削除
2025-07-06 3か所それぞれのモニタリングできた．
2025-07-06 カメラの取り付け位置の関係上，90度反時計回りに回転させたので初期設定から軸がずれるはず．
2025-07-06 Build-3を作成
2025-07-06 Build-5を作成
2025-07-06 BNO055のデータシートを追加
2025-07-06 コードを整形
2025-07-06 気圧計測，高度算出，落下検知をできるようにした．
2025-07-07 修正した．発注する．
2025-07-07 FlightModuleの機能を移植し，FlightModeなどを再現できるようにした．試験用
2025-07-07 コードを整形．認識性は悪いかも．
2025-07-07 CANのIDを更新．優先順位はまた後日決定する．
2025-07-07 kmlファイルをgeminiに生成してもらったけれど微妙
2025-07-07 頂点検知試験を実施した．
2025-07-08 何を修正したか忘れてしまった．
2025-07-08 電圧計測の送受信機能を追加
2025-07-08 電圧をCANで送信する機能を追加
2025-07-08 基準気圧の設定方法を記述
2025-07-08 一部だけログ保存の項目に合わせた
2025-07-08 不要な環境を削除し，新たな環境を構築
2025-07-16 ブロック図をいくつか作成
2025-07-16 BOMは出力した方が部品実装の際に便利
2025-07-16 ロングラン試験の結果を追加
2025-07-16 通信試験の結果を追加
2025-07-16 きれいなLiFePO4の放電カーブが取れた
2025-07-16 バイト数の間違いを訂正（float型は4バイトだよ）
2025-07-16 CANによるデータ送信を確認
2025-07-16 SensingModuleの代わりとして実装
2025-07-16 OutputPinクラスでLEDの点滅を実装
2025-07-17 バスを監視するメソッドを追加．Powerだけ負の値で出力される．
2025-07-17 ID名を変更
2025-07-17 busMonitorを実装
2025-07-17 テスト用でreceiceBusMonitorを実装
2025-07-17 入力部の動作を確認
2025-07-17 METARから情報を取得する
2025-07-19 外部，内部給電監視情報を送信する機能を追加
2025-07-19 シリアルプリントの変数名と表示される変数名を揃えた
2025-07-21 各モジュールの写真を追加
2025-07-21 外観の写真を追加
2025-07-21 その他のパーツを追加
2025-07-21 場所ずれていたので修正
2025-07-21 白色を作成
2025-07-21 Teleplotで地上局を作成した
2025-07-21 LoRaで受信する項目を追加
2025-07-21 groundからexternalに変更
2025-07-21 基本的な動作とフライト中に主流路を閉じる機能まで実装
2025-07-21 受信する項目を追加，整理
2025-07-21 通信試験のログを追加
2025-07-23 地上局のファイルとフォルダの追加
2025-07-23 T-BEAM用の環境構築
2025-07-23 T-BEAM用の環境構築Ⅱ
2025-07-23 いったんプッシュ
2025-07-24 PlatformIOの環境を更新
2025-07-24 T-BEAM用の環境構築Ⅲ,GPS取得成功
2025-07-24 いったん揃えます
2025-07-24 いったん揃えますⅡ
2025-07-24 すばるからの情報を受信できた
2025-07-24 新たな環境を構築
2025-07-24 onbord,telemetry共に情報受信できた!!!!!
2025-07-25 T-BeamをTeleplotの仕様に合わせる．
2025-07-25 写真を追加
2025-07-25 通常の仕様に戻した
2025-07-25 Teleplotでの表示ができるようになった．
2025-08-01 T-BEAMのディスプレイ表示を可能にした
2025-08-01 燃焼実験仕様に直す必要あり
2025-08-01 groundからexternalへと名称を変更
2025-08-01 外部給電のモニタリング機能と各電力モニターICの温度を保存可能にした
2025-08-01 SensingModuleからの情報をすべてTeleplotでモニターできるようにした
2025-08-02 H-62用に座標軸を再設定
2025-08-02 ディスプレイに表示する名称を改善
2025-08-02 ittannpussyu
2025-08-02 T-BEAM側の位置情報表示を改善
2025-08-02 sendFlightの引数を変更
2025-08-02 mWではなくWに変更
2025-08-02 mWからWに変更
2025-08-02 テレメトリー周りを修正中
2025-08-02 全てのログを回収できそう
2025-08-02 T-Beam環境での開発開始
2025-08-02 とりあえずプッシュ
2025-08-02 バッテリーインジケーターを追加
2025-08-02 バッテリーインジケーターの処理を組み込んだ
2025-08-02 ページ切り替えを実装
2025-08-02 一旦プッシュ
2025-08-03 RSSIのバー表示
2025-08-03 無線によるサーボモーターの動作を実装
2025-08-03 コマンドを受信による処理を実装
2025-08-03 LoRaのパケットを最適化
2025-08-03 サーボモーターへのコマンドを実装．名前は変えたい
2025-08-03 offにする機能を追加
2025-08-03 回収時の動作を追加
2025-08-03 虹色に光らせよう！！！！！！！
2025-08-03 コードをリファクタリング
2025-08-03 FlightModuleの動作を再現
2025-08-03 Teleplotのレイアウトを追加
2025-08-05 いったんプッシュⅡ
2025-08-05 センシングモジュールの仕様に合わせた
2025-08-05 試していた関数を結合
2025-08-05 SensingModuleのT-BEAM受信側一旦完了
2025-08-05 レイアウトの保存
2025-08-07 マニュアルを作成
2025-08-07 とりあえず完成
2025-08-08 供給路が開くように変更
2025-08-08 受け取る情報を追加
2025-08-08 読みだすデータを追加
2025-08-08 分離保護時間などを追加
2025-08-08 Teleplotのレイアウトを新規作成
2025-08-08 Teleplotのレイアウトを更新
2025-08-08 マニュアルを更新
2025-08-08 表示される情報を更新
2025-08-08 表示を更新
2025-08-08 回収時の動作をコメントとして記載
2025-08-08 余計なコメントを削除
2025-08-08 表示させるデータを増やした．
2025-08-08 分離保護時間などを表示できるようにした
2025-08-08 実際は使用しないけれどコミット
2025-08-12 文字を認識しやすくした
2025-08-12 PCが調子いい時と拗ねるときがあるので早めにプッシュ！
2025-08-12 虹色に光らせよう！！
2025-08-14 FlightTimeの型を修正
2025-08-14 レイアウト変更
2025-08-14 環境を整理
2025-08-14 基準気圧を改定
2025-08-14 CSV形式でのログ保存に対応
2025-08-14 名前を変更
2025-08-17 供給路，主流路，どちらも開になるようにした
2025-08-17 上部のコメントを更新
2025-08-17 ヘッダーの名前を更新
2025-08-17 上部のコメントを追加
2025-08-17 現在の分離時間，分離保護時間を表示できるように変更
2025-08-17 レイアウト見やすくした
2025-08-17 コメントを変更
2025-08-17 ディスプレイ表示の機能を追加
2025-08-17 識別用の機能を追加
2025-08-17 センシングモジュール接続時にモールス信号がなるように変更
2025-08-17 基準気圧をアップリンクできるようにした
2025-08-17 使用しないコマンドを無効に
2025-08-18 21st無線調整シートにより変更
2025-08-18 8/18 10:00の基準気圧
2025-08-18 起動時の画面を更新
2025-08-18 起動画面の待機時間を設定
2025-08-18 電流の表示を更新，周波数帯を設定
2025-08-18 現在地とロケットからの位置情報を元に2点間の距離を表示
2025-08-19 Doxygenによるコメントを記載
2025-08-19 3Dmodel画像を追加
2025-08-20 コメントを追加
2025-08-20 T-BeamをWebServerとして使えるテストコードを書いてみた
2025-08-20 WebServer関連のライブラリを追加
2025-09-02 写真を複数追加
2025-09-02 試験用プログラムを作成してた
2025-09-02 AJAXを追加してみた
2025-09-02 環境を更新
2025-09-02 Heroを追加
2025-09-02 gifアニメーションを追加
2025-09-02 余白を削除
2025-09-26 画像を追加
2025-10-17 バルブの角度を変更
2025-10-25 FlightModueで行った試験データを格納
2025-10-25 PowerModuleのブロック図を作成
2025-10-25 CAN通信周りの図を作成
2025-10-25 FlightModuleのブロック図を作成
2025-10-25 SSIDとPasswordを非公開に
2025-10-26 プロジェクト報告書を作成
2025-10-26 ドキュメントのURLを更新
2025-10-31 ブロック図を作成
2025-10-31 Heroの位置を調整
2025-10-31 目次を調整
2025-11-06 バグ修正
2025-11-06 特に変更はしていない
2025-11-06 CANに関する項目を追記
2025-12-02 BMI088のデータシートを追加
2025-12-02 MMC5983MAのデータシートを追加
2025-12-02 MPU9250のデータシートを追加
2025-12-02 MPU9250のライブラリを追加
2025-12-02 BNO055ライブラリの初期化、データ取得、キャリブレーション機能を追加
2025-12-02 Madgwickフィルターを追加
2025-12-02 Arduino UNO R4 の環境を追加
2025-12-02 BNO055, MPU9250のテストコードを追加
2025-12-02 センサーのテストデータを追加
2025-12-28 燃焼実験用モジュールを作成中
2026-01-07 内容を追記・更新
2026-01-14 燃焼実験用のモジュール完成
2026-01-14 READMEの製作開始
2026-01-15 基板発注完了
2026-01-16 ADXL375の単体テスト
2026-01-16 NucleoF756ZGを追加
2026-02-21 ライブラリを新規作成・更新
2026-02-21 テストデータを保存
2026-02-21 特に変更なし
2026-02-21 特に変更無し
2026-02-21 修正したライブラリを実装
2026-02-21 様々な加速度センサーをテスト
2026-02-21 AIに作ってもらった簡易ガイド
2026-02-21 COMとF.Fabを追加
2026-02-21 開発用ボードを作成中
2026-02-21 バグっていたので修正
