# Repository tokai-student-rocket-project/H-62-Avionics (continued)

## KiCad design KiCAD/FlightModule/FlightModule.kicad_pcb

Parts:
D1, D2, D3, D7, D12: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_TopBottom
R1, R2, R26, R31: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4, R5, R13, R21: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
Ux1: ARDUINO_MKR_WAN_1310; BOARD_ARDUINO_MKR_WAN_1310; PARTREV 06/27/2019

Connections:
+3.3V: R1.1, R2.1, R26.1, R31.1, Ux1.J5_12 (+3V3); also elsewhere on the board
+5V: Ux1.J5_13 (VIN); also elsewhere on the board
BUZZER: Ux1.J3_5 (PA04/D18(PWM)/AIN(4)/A3); also elsewhere on the board
CAN_RECEIVE_STATUS: R13.1, Ux1.J3_9 (PA22/D0(PWM))
CAN_SEND_STATUS: R21.1, Ux1.J3_10 (PA23/D1(PWM))
FLIGHT_PIN: Ux1.J3_11 (PA10/D2(PWM)); also elsewhere on the board
GND: D1.1 (K), D2.1 (K), D3.1 (K), D7.1 (K), D12.1 (K), Ux1.J5_11 (GND); also elsewhere on the board
GNSS_STATUS: R5.1, Ux1.J3_14 (PB11/D5(PWM))
I2C_SCL: Ux1.J5_7 (PA09/D12(PWM)/SCL(SC2)); also elsewhere on the board
I2C_SDA: Ux1.J5_6 (PA08/D11/SDA(SC2)); also elsewhere on the board
LORA_RECEIVE_STATUS: R3.1, Ux1.J3_7 (PA06/D20/AIN(6)/A5)
LORA_SEND_STATUS: R4.1, Ux1.J3_8 (PA07/D21/AIN(7)/A6)
unnamed: D1.2 (A), R3.2
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: D7.2 (A), R13.2
unnamed: D12.2 (A), R21.2
SN3: Ux1.J3_13 (PB10/D4(PWM)); also elsewhere on the board
SN4: Ux1.J3_12 (PA11/D3(PWM)); also elsewhere on the board
SPI_CS_MCP2515: R2.2, Ux1.J5_1 (PA20/D6(PWM)); also elsewhere on the board
SPI_MISO: Ux1.J5_5 (PA19/D10(PWM)/CIPO(SC1)); also elsewhere on the board
SPI_MOSI: Ux1.J5_3 (PA16/D8(PWM)/COPI(SC1)); also elsewhere on the board
SPI_SCLK: Ux1.J5_4 (PA17/D9/SCK(SC1)); also elsewhere on the board
SPI_~CS_FeRAM0: R1.2, Ux1.J5_2 (PA21/D7(PWM)); also elsewhere on the board
SPI_~CS_FeRAM1: R26.2, Ux1.J3_3 (PB02/D16/AIN(10)/A1); also elsewhere on the board
SPI_~CS_FeRAM2: R31.2, Ux1.J3_4 (PB03/D17/AIN(11)/A2); also elsewhere on the board

Notes on the sheet:
付属品
GSMダイポールアンテナ(Arduino MKR WAN用アンテナ)
Mount
MKR WAN 1310
Status

Parts:
C1: 330uF; CP_Elec_10x10
C10, C11: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D4: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: GS1010FL; D_SOD-123F
PS1: M78AR05-0.5; M78AR03305; Manufacturer_Part_Number M78AR05-0.5
R6: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5: NCV8114BSN330T1G; TSOT-23-5

Connections:
+3.3V: C11.1, U5.5 (OUT); also elsewhere on the board
+5V: C10.1, PS1.3 (+VOUT), U5.1 (IN), U5.3 (EN); also elsewhere on the board
+12V: C1.1, D5.2 (A), R6.1; also elsewhere on the board
GND: C1.2, C10.2, C11.2, D4.1 (K), PS1.2 (GND), U5.2 (GND); also elsewhere on the board
unnamed: D4.2 (A), R6.2
unnamed: D5.1 (K), PS1.1 (+VIN)

Notes on the sheet:
本当は RT9080-33GJ5
Power Good
Linear Regulator
Switching Regulator
To MCU
From BUS
From DCDC

Parts:
C4, C5, C13: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C7: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: DF11B-8DP-2DS; DF11-8DP-2DS
R11: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R14: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U8: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U9: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
Y1: 8MHz; Crystal_SMD_HC49-SD

Connections:
+3.3V: C4.2, C5.2, R14.2, U8.5 (Vio), U9.20 (VDD); also elsewhere on the board
+5V: C13.2, U8.3 (VDD); also elsewhere on the board
+12V: J1.1, J1.2; also elsewhere on the board
CAN_H: J1.7, J1.8, R11.1, U8.7 (CANH)
CAN_L: J1.5, J1.6, R11.2, U8.6 (CANL)
CAN_RX: U8.4 (RXD), U9.2 (RXCAN)
CAN_TX: U8.1 (TXD), U9.1 (TXCAN)
GND: C4.1, C5.1, C6.2, C7.2, C13.1, J1.3, J1.4, U8.2 (VSS), U8.8 (STBY), U9.10 (VSS); also elsewhere on the board
unnamed: R14.1, U9.19 (~RESET)
OSC1: C6.1, U9.9 (OSC1), Y1.2
OSC2: C7.1, U9.8 (OSC2), Y1.1
SPI_CS_MCP2515: U9.18 (~CS); also elsewhere on the board
SPI_MISO: U9.17 (SO); also elsewhere on the board
SPI_MOSI: U9.16 (SI); also elsewhere on the board
SPI_SCLK: U9.14 (SCK); also elsewhere on the board

Notes on the sheet:
BUS：CAN + 電源ライン
組み立て位置により終端抵抗の 取り付けを有無を決めること
CANコントローラー
CANトランシーバー

Parts:
C16, C17: 1uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
R27: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28: 0R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R29, R30: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U3: SAM-M8Q-0-10; MODULE_SAM-M8Q-0-10; PARTREV R07

Connections:
+3.3V: C16.1, C17.1, R27.1, R28.1, R29.1, R30.1, U3.2 (VCC_IO), U3.17 (VCC); also elsewhere on the board
EXTINT_SAM-M8Q: U3.19 (EXTINT0)
GND: C16.2, C17.2, U3.1 (GND), U3.4 (GND), U3.5 (GND), U3.6 (GND), U3.10 (GND), U3.11 (GND), U3.15 (GND), U3.16 (GND), U3.20 (GND); also elsewhere on the board
I2C_SCL: R29.2, U3.12 (SCL); also elsewhere on the board
I2C_SDA: R30.2, U3.9 (SDA); also elsewhere on the board
unnamed: R28.2, U3.3 (V_BCKP)
UART_RXD: R27.2, U3.14 (RXD)
UART_TXD: U3.13 (TXD)

Notes on the sheet:
ジャンパ抵抗
GNSS

Parts:
BZ1: UGCM1205XP; Buzzer_12x9.5RM7.6
C8, C9, C14, C15, C18: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J4: DF51-2P-2DS
Q3: 2SC3325-Y; SC-59_Handsoldering
R22: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R23, R24, R25: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U2, U4: MB85RQ8MX; SOIC-16W_7.5x10.3mm_P1.27mm
U7: TC7S14F; TSOT-23-5_HandSoldering

Connections:
+3.3V: C9.2, C14.1, C15.1, C18.1, R24.2, U1.1 (~HOLD(IO3)), U1.2 (VDD), U1.9 (~WP(IO2)), U2.1 (~HOLD(IO3)), U2.2 (VDD), U2.9 (~WP(IO2)), U4.1 (~HOLD(IO3)), U4.2 (VDD), U4.9 (~WP(IO2)), U7.5 (VCC); also elsewhere on the board
+5V: BZ1.1 (-); also elsewhere on the board
BUZZER: R22.1; also elsewhere on the board
FLIGHT_PIN: U7.4; also elsewhere on the board
GND: C8.1, C9.1, C14.2, C15.2, C18.2, J4.1, Q3.2 (E), R23.1, U1.10 (VSS), U2.10 (VSS), U4.10 (VSS), U7.3 (GND); also elsewhere on the board
unnamed: BZ1.2 (+), Q3.3 (C)
unnamed: C8.2, R25.2, U7.2
unnamed: J4.2, R24.1, R25.1
unnamed: Q3.1 (B), R22.2, R23.2
SPI_MISO: U1.8 (SO(IO1)), U2.8 (SO(IO1)), U4.8 (SO(IO1)); also elsewhere on the board
SPI_MOSI: U1.15 (SI(IO0)), U2.15 (SI(IO0)), U4.15 (SI(IO0)); also elsewhere on the board
SPI_SCLK: U1.16 (SCK), U2.16 (SCK), U4.16 (SCK); also elsewhere on the board
SPI_~CS_FeRAM0: U1.7 (~CS); also elsewhere on the board
SPI_~CS_FeRAM1: U2.7 (~CS); also elsewhere on the board
SPI_~CS_FeRAM2: U4.7 (~CS); also elsewhere on the board

Notes on the sheet:
現在の状態を把握するため
FeRAM2
FeRAM0
FeRAM1
ブザー
フライトピン

Parts:
D8, D10: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D9, D11: GS1010FL; D_SOD-123F
J5: DF51A-4P-2DSA
Q1, Q2: AO3400A; SOT-23
R15, R18: 300R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16, R19: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17, R20: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+12V: D9.1 (K), D11.1 (K), J5.2, J5.4, R17.1, R20.1; also elsewhere on the board
GND: Q1.2 (S), Q2.2 (S), R16.1, R19.1; also elsewhere on the board
unnamed: D8.2 (A), R17.2
unnamed: D8.1 (K), D9.2 (A), J5.3, Q1.3 (D)
unnamed: D10.2 (A), R20.2
unnamed: D10.1 (K), D11.2 (A), J5.1, Q2.3 (D)
unnamed: Q1.1 (G), R15.2, R16.2
unnamed: Q2.1 (G), R18.2, R19.2
SN3: R15.1; also elsewhere on the board
SN4: R18.1; also elsewhere on the board

Notes on the sheet:
12V ラインをMOSFETにより駆動
SN4
SN3

Board: 2 copper layers, 90.0 x 70.0 mm, 74 parts (19 on the bottom side), 48 nets.

File KiCAD/FlightModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
BZ1,Buzzer_12x9.5RM7.6,1,UGCM1205XP,
C1,CP_Elec_10x10,1,330uF,
"C10, C11, C16, C17",805,4,1uF,
"C13, C14, C15, C18, C4, C5, C8, C9",603,8,0.1uF,
"C6, C7",603,2,15pF,
"D1, D12, D2, D3, D7",603,5,Blue,
"D10, D4, D8",603,3,Green,
"D11, D5, D9",D_SOD-123F,3,GS1010FL,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad_TopBottom,4,MountingHole_Pad,
J1,DF11-8DP-2DS,1,DF11B-8DP-2DS,
J4,DF51-2P-2DS,1,DF51-2P-2DS,
J5,DF51A-4P-2DSA,1,DF51A-4P-2DSA,
PS1,M78AR03305,1,M78AR05-0.5,
"Q1, Q2",SOT-23,2,AO3400A,
Q3,SC-59_Handsoldering,1,2SC3325-Y,
"R1, R2, R22, R26, R29, R30, R31",603,7,4.7kR,
R11,603,1,120R,
"R13, R21, R3, R4, R5",603,5,680R,
"R14, R16, R19, R23, R24, R25",603,6,10kR,
"R15, R18",603,2,300R,
"R17, R20, R6",603,3,2.4kR,
R27,603,1,100kR,
R28,603,1,0R,
"U1, U2, U4",SOIC-16W_7.5x10.3mm_P1.27mm,3,MB85RQ8MX,
U3,MODULE_SAM-M8Q-0-10,1,SAM-M8Q-0-10,
U5,TSOT-23-5,1,NCV8114BSN330T1G,
U7,TSOT-23-5_HandSoldering,1,TC7S14F,
U8,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2562-E-SN,
U9,TSSOP-20_4.4x6.5mm_P0.65mm,1,MCP2515-xST,
UX1,BOARD_ARDUINO_MKR_WAN_1310,1,ARDUINO_MKR_WAN_1310,
Y1,Crystal_SMD_HC49-SD,1,8MHz,

## KiCad design KiCAD/18650BatteryModule/18650BatteryModule.kicad_pcb

Parts:
BT1, BT2, BT3, BT4: 1042; BAT_1042; PARTREV E
D1: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Polyfuse; Fuse_Bourns_MF-RHT300
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_TopBottom
J1: DF1B-2S-2.5R
J2: DF11-8DP-2DS
R1: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1: TestPoint; TestPoint_THTPad_D1.0mm_Drill0.5mm
TP2: TestPoint_GND; TestPoint_THTPad_1.0x1.0mm_Drill0.5mm

Connections:
/12V: J2.1, J2.2, R1.1
/BUS_GND: D1.1 (K), J2.3, J2.4
/CAN_H: J2.7, J2.8
/CAN_L: J2.5, J2.6
GND: BT4.N, J1.1, TP2.1
unnamed: BT1.N, BT2.P
unnamed: BT1.P, F1.2
unnamed: BT2.N, BT3.P
unnamed: BT3.N, BT4.P
unnamed: D1.2 (A), R1.2
unnamed: F1.1, J1.2, TP1.1

Notes on the sheet:
From Power Module
BUS

Board: 2 copper layers, 94.0 x 70.0 mm, 15 parts (2 on the bottom side), 11 nets.

File KiCAD/18650BatteryModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"BT1, BT2, BT3, BT4",BAT_1042,4,1042,
D1,0603,1,Green,
F1,Fuse_Bourns_MF-RHT300,1,Polyfuse,
J1,DF1B-2S-2.5R,1,DF1B-2S-2.5R,
J2,DF11-8DP-2DS,1,DF11-8DP-2DS,
R1,0603,1,2.4kR,
TP1,TestPoint_THTPad_D1.0mm_Drill0.5mm,1,TestPoint,
TP2,TestPoint_THTPad_1.0x1.0mm_Drill0.5mm,1,TestPoint_GND,

## KiCad design KiCAD/SubaruPlate/SubaruPlate.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_TopBottom

Connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Notes on the sheet:
M3 Mount
