# Repository tokai-student-rocket-project/H-62-Avionics

File README.md:

# H-62-Avionics

H-62搭載計器　すばる1.3 | 2025年度 夏季 能代 NOGO

すばる1.2 の機能を引き継ぎつつ海打上げ実験用に改良を加えました

- 水密機能の搭載
- 基板径をΦ90に変更
- LYLYGO開発ボードを活用した地上局

## ドキュメント
- [PDR](./Document/PDR/Subaru1.3_PDR.pdf)
- [CDR](./Document/CDR/Subaru1.3_CDR.pdf)
- [報告書](./Document/Report/Report.md)

## ディレクトリ構成
### [Document](./Document/)
資料を格納するディレクトリ

### [KiCAD](./KiCAD/)
KiCADのプロジェクトファイルを格納するディレクトリ
- [Flight Module](./KiCAD/FlightModule/)
- [Battery Module](./KiCAD/BatteryModule/)
- [Power Module](./KiCAD/PowerControlModule/)
- [Battery Module](./KiCAD/18650BatteryModule/)
- [Sensing Module](./KiCAD/SensingModule/)
- [Valve Control Module](./KiCAD/ValveControlModule/)
- [Subaru Plate](./KiCAD/SubaruPlate/)

### [lib](./lib/)
ライブラリを格納するディレクトリ

Lib_ から始まるライブラリはラッパーライブラリとなっています

### [src](./src/)
ソースコードを格納するディレクトリ

**Flight** : 搭載計器のソースコード
- [Flight Module](./src/Flight/FlightModule/FlightModule.cpp)
- [Power Module](./src/Flight/PowerModule/PowerModule.cpp)
- [Sensing Module](./src/Flight/SensingModule/SensingModule.cpp)
- [Valve Control Module](./src/Flight/ValveControlModule/ValveControlModule.cpp)

**Ground** : 地上局のソースコード
- [Ground Flight Module](./src/Ground/CSV/FlightModule/FlightModule.cpp)
- [Ground Sensing Module](./src/Ground/CSV/SensingModule/SensingModule.cpp)
- [Sea Flight Module](./src/Ground/T-BEAM/FlightModule/FlightModule.cpp)
- [Teleplot Ground Flight Module](./src/Ground/Teleplot/FlightModule/FlightModule.cpp)
  - [Teleplot Layout](./src/Ground/Teleplot/FlightModule/teleplot_layout_FlightModule.json)

**LogDumper** : ログ読み出しのソースコード
- [Flight Module](./src/LogDumper/FlightModule/FlightModule.cpp)
- [Sensing Module](./src/LogDumper/SensingModule/SensingModule.cpp)

## KiCad design KiCAD/THRValveControlModule/THRValveControlModule.kicad_pcb

Parts:
D1: RB160M-30TR; D_SOD-123
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_Via
R1, R2, R15: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: XIAO-RA4M1-SMD

Connections:
+3.3V: R1.1, R2.1, R15.1, U1.12 (3V3); also elsewhere on the board
+5V: D1.2 (A); also elsewhere on the board
CAN_RXD: U1.10 (P110_MISO9); also elsewhere on the board
CAN_TXD: U1.11 (P109_MOSI9); also elsewhere on the board
GND: U1.13 (GND), U1.30 (GND_2); also elsewhere on the board
I2C_SCL: R2.2, U1.6 (P100_ADC22_SCL1); also elsewhere on the board
I2C_SDA: R1.2, U1.5 (P206_SDA1); also elsewhere on the board
unnamed: D1.1 (K), U1.14 (5V)
Periferal_Speaker: U1.15 (P408_RX9); also elsewhere on the board
Periferal_SwitchA: U1.17 (P013); also elsewhere on the board
RS485_DI: U1.7 (P302_TXD2); also elsewhere on the board
RS485_EN: U1.1 (P014_AN09_DAC); also elsewhere on the board
RS485_RO: U1.8 (P301_RXD2); also elsewhere on the board
SPI_ADXL375_~CS: U1.18 (P012); also elsewhere on the board
SPI_FeRAM0_~CS: R15.2, U1.16 (P409_TX9); also elsewhere on the board
SPI_ICM-42688_~CS: U1.22 (P103_SS0); also elsewhere on the board
SPI_SCLK: U1.21 (P102_SCK0); also elsewhere on the board
SPI_SDI: U1.19 (P101_ADC21_MOSI0); also elsewhere on the board
SPI_SDO: U1.20 (P104_MISO0); also elsewhere on the board
ServoA_PWM: U1.9 (P111_SCK9); also elsewhere on the board
ServoB_PWM: U1.4 (P002_ADC02_AMP00); also elsewhere on the board
Umbilical_GseIgnition: U1.3 (P001_ADC01_AMP0-); also elsewhere on the board
Umbilical_GseValve: U1.2 (P000_ADC00_AMP0+); also elsewhere on the board

Parts:
C2: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D2: P4KE15A; D_DO-41_SOD81_P2.54mm_Vertical_KathodeUp
J1: B4B-XH-A(LF)(SN); JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2, J3: B3B-XH-A(LF)(SN); JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
R6: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U5: MAX485E; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C2.1, U5.8 (VCC); also elsewhere on the board
GND: C2.2, D2.1 (A1), J1.1, J2.1, J3.1, U5.5 (GND); also elsewhere on the board
RS485_A: J1.3, R6.1, U5.6 (A)
RS485_B: J1.4, R6.2, U5.7 (B)
RS485_DI: U5.4 (DI); also elsewhere on the board
RS485_EN: U5.2 (~RE), U5.3 (DE); also elsewhere on the board
RS485_RO: U5.1 (RO); also elsewhere on the board
SC8721_VOUT: D2.2 (A2), J1.2, J2.2, J3.2; also elsewhere on the board
ServoA_PWM: J2.3; also elsewhere on the board
ServoB_PWM: J3.3; also elsewhere on the board

Notes on the sheet:
PWMサーボ A
PWMサーボ B
B3M-SC-1170-A

Parts:
C4: 1000u; CP_Radial_D12.5mm_P5.00mm
D5: MA10EB045; MA_DO-221BC
J4: XT30PW-M; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
U6: SC8721; StrawberryLinux_SC8721
U7: BP5293-50

Connections:
+5V: U7.3 (VOUT); also elsewhere on the board
GND: C4.2, J4.1, U6.1 (GND), U6.2 (GND), U6.5 (GND), U6.10 (GND), U6.18 (GND), U6.19 (GND), U6.20 (GND), U7.2 (GND); also elsewhere on the board
I2C_SCL: U6.7 (SCL); also elsewhere on the board
I2C_SDA: U6.6 (SDA); also elsewhere on the board
unnamed: D5.2 (A), J4.2
SC8721_CSO: U6.9 (CSO)
SC8721_VIN: D5.1 (K), U6.3 (VIN), U6.4 (VIN)
SC8721_VOUT: C4.1, U6.13 (VOUT), U6.14 (VOUT), U6.15 (VOUT), U7.1 (VIN); also elsewhere on the board

Parts:
C6, C7, C8, C9: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C18: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D6: 1N4148W; D_SOD-123
J5: DF51A-4P-2DSA
J6: SSD1306; PinHeader_1x04_P2.54mm_Vertical
LS1: UGCT7525AN4
Q1: IRLML6344TRPBFTR; SOT-23_Handsoldering
R7, R8, R10, R11, R12, R13: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW2: SKRPACE010
U8, U9: TC7S14F; SOT-23-5
U10: MB85RQ8MX; SOIC-16W_7.5x10.3mm_P1.27mm

Connections:
+3.3V: C7.1, C9.1, C18.1, J6.2, R7.2, R11.2, R13.1, U8.5 (VCC), U9.5 (VCC), U10.1 (~HOLD(IO3)), U10.2 (VDD), U10.9 (~WP(IO2)); also elsewhere on the board
+5V: D6.1 (K), LS1.2; also elsewhere on the board
GND: C6.2, C7.2, C8.2, C9.2, C18.2, J5.1, J5.3, J6.1, Q1.2 (S), R10.1, SW2.3 (K), SW2.4 (A), U8.3 (GND), U9.3 (GND), U10.10 (VSS); also elsewhere on the board
I2C_SCL: J6.3; also elsewhere on the board
I2C_SDA: J6.4; also elsewhere on the board
unnamed: C6.1, R8.2, U8.2
unnamed: C8.1, R12.2, U9.2
unnamed: D6.2 (A), LS1.1, Q1.3 (D)
unnamed: J5.2, R11.1, R12.1
unnamed: J5.4, R7.1, R8.1
unnamed: Q1.1 (G), R9.1, R10.2
Periferal_Speaker: R9.2; also elsewhere on the board
Periferal_SwitchA: R13.2, SW2.1, SW2.2; also elsewhere on the board
SPI_FeRAM0_~CS: U10.7 (~CS); also elsewhere on the board
SPI_SCLK: U10.16 (SCK); also elsewhere on the board
SPI_SDI: U10.15 (SI(IO0)); also elsewhere on the board
SPI_SDO: U10.8 (SO(IO1)); also elsewhere on the board
Umbilical_GseIgnition: U8.4; also elsewhere on the board
Umbilical_GseValve: U9.4; also elsewhere on the board

Notes on the sheet:
アンビリカル イグニッション
SSD1306
アンビリカル バルブ
FeRAM0
ユーザー入力
スピーカー

Parts:
C1: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J7: DF51A-8DP-2DS
R5: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1: IS-2235; SW_CK_JS202011CQN_DPDT_Straight
U4: ATA6561; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.2, U4.3 (VDD), U4.5 (Vio); also elsewhere on the board
CAN_H: J7.7, J7.8, R5.1, U4.7 (CANH)
CAN_L: J7.5, J7.6, SW1.1 (A), U4.6 (CANL); also elsewhere on the board
CAN_RXD: U4.4 (RXD); also elsewhere on the board
CAN_TXD: U4.1 (TXD); also elsewhere on the board
GND: C1.1, J7.1, J7.2, U4.2 (VSS), U4.8 (STBY); also elsewhere on the board
unnamed 17: R5.2, SW1.2 (B); also elsewhere on the board
SC8721_VOUT: J7.3, J7.4; also elsewhere on the board

Notes on the sheet:
CAN インターフェース

Board: 2 copper layers, 99.0 x 75.0 mm, 51 parts (0 on the bottom side), 37 nets.

Other parts of the board:
END 120R: IS-2235; SW_CK_JS202011CQN_DPDT_Straight
R3, R4: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW A: SKRPACE010
U2: ICM-42688; StrawberryLinux_ICM-42688-P
U3: ADXL375; StrawberryLinux_ADXL375

Their connections:
+3.3V: R3.1, R4.1, U2.1 (VDD), U2.2 (VDDIO), U3.9 (VS), U3.10 (VDDI/O); also elsewhere on the board
CAN_L: END 120R.1 (A); also elsewhere on the board
GND: SW A.3 (K), SW A.4 (A), U2.10 (GND), U3.1 (GND), U3.8 (GND); also elsewhere on the board
unnamed 17: END 120R.2 (B); also elsewhere on the board
Periferal_SwitchA: SW A.1, SW A.2; also elsewhere on the board
SPI_ADXL375_~CS: R4.2, U3.5 (~CS); also elsewhere on the board
SPI_ICM-42688_~CS: R3.2, U2.6 (~CS); also elsewhere on the board
SPI_SCLK: U2.3 (SCL/SCLK), U3.2 (SCK/SCLK); also elsewhere on the board
SPI_SDI: U2.4 (SDA/SDI), U3.3 (SDA/SDI/SDIO); also elsewhere on the board
SPI_SDO: U2.5 (AD0/SDO), U3.4 (SDO/ALT_ADDRESS); also elsewhere on the board

File KiCAD/THRValveControlModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C2, C6, C7, C8, C9",0603,6,0.1u,
C18,0603,1,0.1uF,
C4,CP_Radial_D12.5mm_P5.00mm,1,1000u,
D1,D_SOD-123,1,RB160M-30TR,
D2,D_DO-41_SOD81_P2.54mm_Vertical_KathodeUp,1,P4KE15A,
D5,MA_DO-221BC,1,MA10EB045,
D6,D_SOD-123,1,1N4148W,
END 120R,SW_CK_JS202011CQN_DPDT_Straight,1,IS-2235,
J1,JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical,1,B4B-XH-A(LF)(SN),
"J2, J3",JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical,2,B3B-XH-A(LF)(SN),
J4,AMASS_XT30PW-M_1x02_P2.50mm_Horizontal,1,XT30PW-M,
J5,DF51A-4P-2DSA,1,DF51A-4P-2DSA,
J6,PinHeader_1x04_P2.54mm_Vertical,1,SSD1306,
J7,DF51A-8DP-2DS,1,DF51A-8DP-2DS,
LS1,UGCT7525AN4,1,UGCT7525AN4,
Q1,SOT-23_Handsoldering,1,IRLML6344TRPBFTR,
"R1, R10, R11, R12, R13, R15, R2, R7, R8",0603,9,10k,
"R3, R4",0603,2,4.7k,
"R5, R6",0603,2,120,
R9,0603,1,1k,
SW A,SKRPACE010,1,SKRPACE010,
U1,XIAO-RA4M1-SMD,1,XIAO-RA4M1-SMD,
U10,SOIC-16W_7.5x10.3mm_P1.27mm,1,MB85RQ8MX,
U2,StrawberryLinux_ICM-42688-P,1,ICM-42688,
U3,StrawberryLinux_ADXL375,1,ADXL375,
U4,SOIC-8_3.9x4.9mm_P1.27mm,1,ATA6561,
U5,SOIC-8_3.9x4.9mm_P1.27mm,1,MAX485E,
U6,StrawberryLinux_SC8721,1,SC8721,
U7,BP5293-50,1,BP5293-50,
"U8, U9",SOT-23-5,2,TC7S14F,

## KiCad design KiCAD/ValveControlModule/ValveControlModule.kicad_pcb

Board: 2 copper layers, 90.0 x 70.0 mm, 52 parts (3 on the bottom side), 36 nets.

Parts:
C1, C3, C4, C5, C11, C12, C13, C14, C18: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C7: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9, C10: 1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 330uF; CP_Elec_10x10
C16: 100uF; CP_Radial_D8.0mm_P3.50mm
C17: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
D1: SMAJ45A; D_SMA
D3: Green; LED_0603_1608Metric
D9: SB34AFC; D_SMA_Handsoldering
H1, H2, H3, H4: MountingHole_Pad; MountingHole_3.2mm_M3_Pad_TopBottom
J1, J3: DF51A-4P-2DS
J2: DF11-8DP-2DS
PS1: M78AR05-0.5; M78AR03305
Q2, Q4: AO3401A; SOT-23_Handsoldering
Q3: AO3400A; SOT-23_Handsoldering
R1, R6: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4: 10K; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 820R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R14, R24, R25, R26, R27: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R13: 100kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: XIAO-RP2040-DIP; XIAO-RP2040-SMD
U2: LT1785xS8; SOIC-8_3.9x4.9mm_P1.27mm
U3: MCP2515-xSO; SOIC-18W_7.5x11.6mm_P1.27mm
U4: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U5: NCV8114BSN330T1G; TSOT-23-5
U6: MB85RQ8MX; SOIC-16W_7.5x10.3mm_P1.27mm
U8, U9: TC7S14F; TSOT-23-5_HandSoldering
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3.3V: C1.2, C3.1, C5.2, C10.1, R4.2, U2.8 (VCC), U3.18 (VDD), U4.5 (Vio), U5.5 (OUT)
+3V3: C12.2, C14.2, C18.1, R9.1, R24.2, R26.2, U1.12 (3V3), U6.1 (~HOLD(IO3)), U6.2 (VDD), U6.9 (~WP(IO2)), U8.5 (VCC), U9.5 (VCC)
+5V: C4.2, C9.1, PS1.3 (+VOUT), U1.14 (VBUS), U4.3 (VDD), U5.1 (IN), U5.3 (EN)
+12V: C15.1, C16.1, C17.1, D1.1 (K), D9.2 (A), J2.1, J2.2, Q4.2 (S), R11.1, R12.1
CAN_H: J2.7, J2.8, R6.2, U4.7 (CANH)
CAN_L: J2.5, J2.6, R6.1, U4.6 (CANL)
CAN_RX: U3.2 (RXCAN), U4.4 (RXD)
CAN_TX: U3.1 (TXCAN), U4.1 (TXD)
GND: C1.1, C3.2, C4.1, C5.1, C6.2, C7.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.1, C15.2, C16.2, C18.2, D1.2 (A), D3.1 (K), J1.1, J2.3, J2.4, J3.1, J3.3, PS1.2 (GND), Q3.2 (S), R14.2, U1.13 (GND), U2.5 (GND), U3.9 (VSS), U4.2 (VSS), U4.8 (STBY), U5.2 (GND), U6.10 (VSS), U8.3 (GND), U9.3 (GND)
unnamed: C11.2, R25.2, U8.2
unnamed: C13.2, R27.2, U9.2
unnamed: D3.2 (A), R11.2
unnamed: D9.1 (K), PS1.1 (+VIN)
unnamed: J1.2, Q2.2 (S)
unnamed: J3.2, R26.1, R27.1
unnamed: J3.4, R24.1, R25.1
unnamed: Q2.3 (D), Q4.3 (D)
unnamed: C17.2, Q2.1 (G), Q4.1 (G), R12.2, R13.1
unnamed: Q3.3 (D), R13.2
unnamed: Q3.1 (G), R10.2, R14.1
unnamed: R4.1, U3.17 (~RESET)
OSC1: C6.1, U3.8 (OSC1), Y1.2
OSC2: C7.1, U3.7 (OSC2), Y1.1
RS485_A: J1.3, R1.1, U2.6 (A)
RS485_B: J1.4, R1.2, U2.7 (B)
RS485_DI: U1.7 (GPIO0/TX), U2.4 (DI)
RS485_EN: U1.2 (GPIO27/ADC1/A1), U2.2 (~RE), U2.3 (DE)
RS485_RO: U1.8 (GPIO1/RX), U2.1 (RO)
SPI_CS_MCP2515: U1.1 (GPIO26/ADC0/A0), U3.16 (~CS)
SPI_MISO: U1.10 (GPIO4/MISO), U3.15 (SO), U6.8 (SO(IO1))
SPI_MOSI: U1.11 (GPIO3/MOSI), U3.14 (SI), U6.15 (SI(IO0))
SPI_SCK: U1.9 (GPIO2/SCK), U3.13 (SCK), U6.16 (SCK)
SPI_~CS_FeRAM0: R9.2, U1.3 (GPIO28/ADC2/A2), U6.7 (~CS)
ServoPower_EN: R10.1, U1.4 (GPIO29/ADC3/A3)
Umbilical_GseIgnition: U1.6 (GPIO7/SCL), U8.4
Umbilical_GseValve: U1.5 (GPIO6/SDA), U9.4

File KiCAD/ValveControlModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C11, C12, C13, C14, C18, C3, C4, C5",0603,9,0.1uF,
"C10, C9",0603,2,1uF,
C15,CP_Elec_10x10,1,330uF,
C16,CP_Radial_D8.0mm_P3.50mm,1,100uF,
C17,0805,1,22uF,
"C6, C7",0603,2,15pF,
D1,D_SMA,1,SMAJ45A,
D3,0603,1,Green,
D9,D_SMA_Handsoldering,1,SB34AFC,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad_TopBottom,4,MountingHole_Pad,
"J1, J3",DF51A-4P-2DS,2,DF51A-4P-2DS,
J2,DF11-8DP-2DS,1,DF11-8DP-2DS,
PS1,M78AR03305,1,M78AR05-0.5,
"Q2, Q4",SOT-23_Handsoldering,2,AO3401A,
Q3,SOT-23_Handsoldering,1,AO3400A,
"R1, R6",0603,2,120,
R10,0603,1,820R,
R11,0603,1,2.4kR,
"R12, R14, R24, R25, R26, R27",0603,6,10kR,
R13,0603,1,100kR,
R4,0603,1,10K,
R9,0603,1,4.7k,
U1,XIAO-RP2040-SMD,1,XIAO-RP2040-DIP,
U2,SOIC-8_3.9x4.9mm_P1.27mm,1,LT1785xS8,
U3,SOIC-18W_7.5x11.6mm_P1.27mm,1,MCP2515-xSO,
U4,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2562-E-SN,
U5,TSOT-23-5,1,NCV8114BSN330T1G,
U6,SOIC-16W_7.5x10.3mm_P1.27mm,1,MB85RQ8MX,
"U8, U9",TSOT-23-5_HandSoldering,2,TC7S14F,
Y1,Crystal_HC49-4H_Vertical,1,8MHz,

## KiCad design KiCAD/BatteryModule/BatteryModule.kicad_pcb

Parts:
BT1, BT2, BT3, BT4, BT5: CR123A; BHC-CR123A
D1: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
F1: Polyfuse; Fuse_Bourns_MF-RHT300
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_TopBottom
J2: DF1B-2S-2.5R
J3: DF11-8DP-2DS
R1: 2.4kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1, TP2: TestPoint; TestPoint_THTPad_D2.0mm_Drill1.0mm

Connections:
/12V: J3.1, J3.2, R1.1
/BUS_GND: D1.1 (K), J3.3, J3.4
/Battery IN: F1.1, J2.2, TP1.1
/CAN_H: J3.7, J3.8
/CAN_L: J3.5, J3.6
GND: BT5.2 (-), J2.1, TP2.1
unnamed: BT1.1 (+), F1.2
unnamed: BT1.2 (-), BT2.1 (+)
unnamed: BT2.2 (-), BT3.1 (+)
unnamed: BT3.2 (-), BT4.1 (+)
unnamed: BT4.2 (-), BT5.1 (+)
unnamed: D1.2 (A), R1.2

Notes on the sheet:
BUS
From Power Module

Board: 2 copper layers, 90.0 x 70.0 mm, 16 parts (0 on the bottom side), 12 nets.

File KiCAD/BatteryModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"BT1, BT2, BT3, BT4, BT5",BHC-CR123A,5,CR123A,
D1,0603,1,Green,
F1,Fuse_Bourns_MF-RHT300,1,Polyfuse,
J2,DF1B-2S-2.5R,1,DF1B-2S-2.5R,
J3,DF11-8DP-2DS,1,DF11-8DP-2DS,
R1,0603,1,2.4kR,
"TP1, TP2",TestPoint_THTPad_D2.0mm_Drill1.0mm,2,TestPoint,
