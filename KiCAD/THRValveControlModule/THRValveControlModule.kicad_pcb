# Repository tokai-student-rocket-project/H-62-Avionics (continued)

## KiCad design KiCAD/SubaruPlate/SubaruPlate.kicad_pcb (continued)

Parts:
C1, C14: 10uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C13: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: Wire_Soldering; PinHeader_1x04_P1.27mm_Vertical
R1, R2, R3, R14, R16: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1, U6: LPS28DFW; CCLGA-7L

Connections:
+3.3V: C1.1, C2.1, C13.1, C14.1, J1.2, R2.1, R3.1, R14.1, R16.1, U1.6 (VDD), U6.2 (SA0), U6.6 (VDD)
GND: C1.2, C2.2, C13.2, C14.2, J1.1, R1.2, U1.5 (GND), U1.7 (LID), U6.5 (GND), U6.7 (LID); also elsewhere on the board
I2C_SCL: J1.4, R3.2, R16.2, U1.3 (SCL), U6.3 (SCL)
I2C_SDA: J1.3, R2.2, R14.2, U1.1 (SDA), U6.1 (SDA)
unnamed: R1.1, U1.2 (SA0)

Notes on the sheet:
I2C Address: 0x5D
I2C Address: 0x5C
データシート LPS28DFW
Adafruit LPS28
STマイクロ LPS28DFW
気圧センサー
I2C バス
参考資料

Board: 2 copper layers, 140.0 x 140.0 mm, 16 parts (2 on the bottom side), 5 nets.

File KiCAD/SubaruPlate/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C14",0603,2,10uF,
"C13, C2",0603,2,0.1uF,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad_TopBottom,4,MountingHole,
J1,PinHeader_1x04_P1.27mm_Vertical,1,Wire_Soldering,
"R1, R14, R16, R2, R3",0603,5,10kR,
"U1, U6",CCLGA-7L,2,LPS28DFW,

## KiCad design KiCAD/PowerControlModule/PowerControlModule.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_Pad_TopBottom

Connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Notes on the sheet:
マウント

Parts:
C13, C16, C17: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14, C15: 15pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C19, C20: 2.2uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D3: Green; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: SMAJ45A; D_SMA
D10: SS2040FL; D_SOD-123F
J3: DF11-8DP-2DS
R21: 3.6kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R24: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R25: 120R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U2: MCP2515-xST; TSSOP-20_4.4x6.5mm_P0.65mm
U8: MCP2562-E-SN; SOIC-8_3.9x4.9mm_P1.27mm
U9: MCP1792x-5002xCB; SOT-23_Handsoldering
Y1: 8MHz; Crystal_HC49-4H_Vertical

Connections:
+3.3V: C13.1, C16.2, R24.2, U2.20 (VDD), U8.5 (Vio); also elsewhere on the board
+5VD: C17.2, C20.1, D10.2 (A), U8.3 (VDD), U9.2 (VO)
+12V: C19.1, D5.1 (K), D10.1 (K), J3.1, J3.2, R21.1, U9.3 (VI); also elsewhere on the board
CAN_H: J3.7, J3.8, R25.2, U8.7 (CANH)
CAN_L: J3.5, J3.6, R25.1, U8.6 (CANL)
CAN_RX: U2.2 (RXCAN), U8.4 (RXD)
CAN_TX: U2.1 (TXCAN), U8.1 (TXD)
GND: C13.2, C14.2, C15.2, C16.1, C17.1, C19.2, C20.2, D3.1 (K), D5.2 (A), J3.3, J3.4, U2.10 (VSS), U8.2 (VSS), U8.8 (STBY), U9.1 (GND); also elsewhere on the board
unnamed: D3.2 (A), R21.2
unnamed: R24.1, U2.19 (~RESET)
OSC1: C14.1, U2.9 (OSC1), Y1.2
OSC2: C15.1, U2.8 (OSC2), Y1.1
SPI_CS_MCP2515: U2.18 (~CS); also elsewhere on the board
SPI_MISO: U2.17 (SO); also elsewhere on the board
SPI_MOSI: U2.16 (SI); also elsewhere on the board
SPI_SCK: U2.14 (SCK); also elsewhere on the board

Notes on the sheet:
終端抵抗．モジュールに応じて取り付ける．
CANトランシーバー
CAN バス
CANコントローラー

Parts:
C1: 220uF; CP_Radial_D6.3mm_P2.50mm
C2, C4: 22uF; C_0805_2012Metric_Pad1.18x1.45mm_HandSolder
C3, C5, C22: 0.1uF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 2200uF; CP_Radial_D18.0mm_P7.50mm
C10: 0.1uF; C_0603_1608Metric
C11: 33uF; CP_Elec_6.3x5.9
C18, C21: 0.056uF; L_0603_1608Metric
D1, D2: Orange; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: SMAJ45A; D_SMA
D7, D8, D9: Red; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2: DF1B-2S-2.5R
Q1, Q2, Q4, Q5, Q7, Q9: AO3401A; SOT-23_Handsoldering
Q3: AO3400A; TSOT-23_HandSoldering
Q6, Q10: AO3401A; SOT-23; not fitted
Q11, Q12: Si4162DY; SOIC-8_3.9x4.9mm_P1.27mm
R3, R6, R7, R22, R26: 10kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R4, R18, R19: 5.6kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R20: 3.3kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R13, R14: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R12: 15mR; R_2512_6332Metric_Pad1.40x3.35mm_HandSolder
R15, R16: 2.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R17: 820; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R27: 10k; R_0603_1608Metric
TH1: Thermistor_NTC; PinHeader_1x02_P2.00mm_Vertical
U3, U4, U6: INA228; VSSOP-10_3x3mm_P0.5mm
U5: LTC4353; MSOP-16_3x4.039mm_P0.5mm
U11: LTC3119; StrawberryLinux_LTC3119

Connections:
+3.3V: C3.1, C5.1, C22.1, D7.2 (A), D8.2 (A), D9.2 (A), R26.1, R27.1, U3.6 (VS), U4.2 (A0), U4.6 (VS), U6.1 (A1), U6.2 (A0), U6.6 (VS); also elsewhere on the board
+12V: R12.2, U6.9 (Vin-); also elsewhere on the board
+VSW: Q7.2 (S), U11.12 (VIN), U11.13 (VIN), U11.14 (RUN)
/PowerControl/BATT: C2.1, J2.2, Q2.2 (S), R4.1
/PowerControl/BATT_LOWER: C21.2, Q12.1 (S), Q12.2 (S), Q12.3 (S), R11.1, U4.9 (Vin-), U5.4 (VIN2)
/PowerControl/BATT_UPPER: Q4.2 (S), R11.2, U4.8 (Vbus), U4.10 (Vin+)
/PowerControl/BUS_LOWER: C1.1, R12.1, U6.8 (Vbus), U6.10 (Vin+), U11.3 (VOUT), U11.4 (VOUT)
/PowerControl/GPU: C4.1, J1.2, Q5.2 (S), R7.1
/PowerControl/GPU_LOWER: C18.2, Q11.1 (S), Q11.2 (S), Q11.3 (S), R10.2, U3.9 (Vin-), U5.13 (VIN1)
/PowerControl/GPU_UPPER: Q9.2 (S), R10.1, U3.8 (Vbus), U3.10 (Vin+)
BATT_EN: R17.1; also elsewhere on the board
GND: C1.2, C3.2, C5.2, C9.2, C10.2, C22.2, J1.1, J2.1, Q3.2 (S), R3.2, R6.2, R8.2, R20.2, R22.2, TH1.2, U3.1 (A1), U3.2 (A0), U3.7 (GND), U4.1 (A1), U4.7 (GND), U5.15 (GND), U6.7 (GND), U11.1 (GND), U11.5 (GND), U11.6 (GND), U11.9 (GND), U11.10 (GND), U11.11 (GND), U11.16 (GND); also elsewhere on the board
I2C_SCL: U3.5 (SCL), U4.5 (SCL), U6.5 (SCL); also elsewhere on the board
I2C_SDA: U3.4 (SDA), U4.4 (SDA), U6.4 (SDA); also elsewhere on the board
LTC3119_PGOOD: R27.2, U11.2 (PGOOD); also elsewhere on the board
LTC4353_EN1: R3.1, U5.16 (EN1); also elsewhere on the board
LTC4353_EN2: R6.1, U5.1 (EN2); also elsewhere on the board
unnamed: D1.2 (A), R15.1
unnamed: D1.1 (K), U5.9 (ONST1)
unnamed: D2.2 (A), R16.1
unnamed: D2.1 (K), U5.8 (ONST1)
unnamed: C9.1, D4.2 (A), R18.1
unnamed: C11.1, D4.1 (K), Q1.2 (S), Q11.5 (D), Q11.6 (D), Q11.7 (D), Q11.8 (D), Q12.5 (D), Q12.6 (D), Q12.7 (D), Q12.8 (D), R15.2, R16.2, R18.2, R19.1, U5.7 (OUT2), U5.10 (OUT1)
unnamed: D7.1 (K), R9.1
unnamed: D8.1 (K), R13.1
unnamed: D9.1 (K), R14.1
unnamed: Q1.3 (D), Q7.3 (D)
unnamed: C11.2, Q1.1 (G), Q7.1 (G), R19.2, R20.1
unnamed: Q2.3 (D), Q4.3 (D)
unnamed: C2.2, Q2.1 (G), Q4.1 (G), R4.2, R5.1
unnamed: Q3.3 (D), R5.2
unnamed: Q3.1 (G), R17.2, R22.1
unnamed: Q5.3 (D), Q9.3 (D)
unnamed: C4.2, Q5.1 (G), Q9.1 (G), R7.2, R8.1
unnamed: Q11.4 (G), U5.12 (GATE1)
unnamed: Q12.4 (G), U5.5 (GATE2)
unnamed: R14.2, U3.3 (~Alert)
unnamed: R13.2, U4.3 (~Alert)
unnamed: C18.1, U5.11 (CPO1)
unnamed: C21.1, U5.6 (CPO2)
unnamed: C10.1, U5.14 (VCC)
unnamed: R9.2, U6.3 (~Alert)
unnamed: U11.7 (VCC), U11.8 (MPPC), U11.15 (PWM/SYNC)
VREF_T1: R26.2, TH1.1; also elsewhere on the board

Notes on the sheet:
SLAVE ADDRESS: 0b1000000
逆流防止ロードスイッチ
今までの接続 H-59 H-60
From Ground Power Unit [GPU] (External)
SLAVE ADDRESS: 0b100 0001
17V
15Vくらい
AO3401A
SLAVE ADDRESS: 100 0101
2:S
3:D
Pch MOSFET
From Battery Module (Internal)
1:G
R7, R8 で分圧して5.5Vくらい
0.015 ohm 1% 3W 電流検出抵抗
R4, R5 で分圧して5.5Vくらい
ソースとドレインのピン番号が反対で接続されていた

Parts:
D11: SS2040FL; D_SOD-123F
R1, R2, R23: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: XIAO-RP2040-DIP; XIAO-RP2040-SMD

Connections:
+3.3V: R1.1, R2.1, R23.1, U1.12 (3V3); also elsewhere on the board
+5V: D11.2 (A); also elsewhere on the board
BATT_EN: U1.7 (GPIO0/TX); also elsewhere on the board
GND: U1.13 (GND); also elsewhere on the board
I2C_SCL: R2.2, U1.6 (GPIO7/SCL); also elsewhere on the board
I2C_SDA: R1.2, U1.5 (GPIO6/SDA); also elsewhere on the board
LTC3119_PGOOD: U1.8 (GPIO1/RX); also elsewhere on the board
LTC4353_EN1: U1.3 (GPIO28/ADC2/A2); also elsewhere on the board
LTC4353_EN2: U1.4 (GPIO29/ADC3/A3); also elsewhere on the board
unnamed: D11.1 (K), U1.14 (VBUS)
SPI_CS_MCP2515: R23.2, U1.1 (GPIO26/ADC0/A0); also elsewhere on the board
SPI_MISO: U1.10 (GPIO4/MISO); also elsewhere on the board
SPI_MOSI: U1.11 (GPIO3/MOSI); also elsewhere on the board
SPI_SCK: U1.9 (GPIO2/SCK); also elsewhere on the board
VREF_T1: U1.2 (GPIO27/ADC1/A1); also elsewhere on the board

Parts:
D6: SS2040FL; D_SOD-123F
PS1: M78AR05-0.5; M78AR03305; Manufacturer_Part_Number M78AR05-0.5

Connections:
+5V: PS1.3 (+VOUT); also elsewhere on the board
+12V: D6.2 (A); also elsewhere on the board
GND: PS1.2 (GND); also elsewhere on the board
unnamed: D6.1 (K), PS1.1 (+VIN)

Notes on the sheet:
逆接続保護ダイオード
Switching Regulator
From BUS
To MCU

Board: 2 copper layers, 90.0 x 70.0 mm, 84 parts (1 on the bottom side), 60 nets.

File KiCAD/PowerControlModule/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
C1,CP_Radial_D6.3mm_P2.50mm,1,220uF,
"C10, C13, C16, C17, C22, C3, C5",0603,7,0.1uF,
C11,CP_Elec_6.3x5.9,1,33uF,
"C14, C15",0603,2,15pF,
"C18, C21",0603,2,0.056uF,
"C19, C20",0603,2,2.2uF,
"C2, C4",0805,2,22uF,
C9,CP_Radial_D18.0mm_P7.50mm,1,2200uF,
"D1, D2",0603,2,Orange,
"D10, D11, D6",D_SOD-123F,3,SS2040FL,
D3,0603,1,Green,
"D4, D5",D_SMA,2,SMAJ45A,
"D7, D8, D9",0603,3,Red,
"H1, H2, H3, H4",MountingHole_3.2mm_M3_Pad_TopBottom,4,MountingHole,
"J1, J2",DF1B-2S-2.5R,2,DF1B-2S-2.5R,
J3,DF11-8DP-2DS,1,DF11-8DP-2DS,
PS1,M78AR03305,1,M78AR05-0.5,
"Q1, Q2, Q4, Q5, Q7, Q9",SOT-23_Handsoldering,6,AO3401A,
"Q11, Q12",SOIC-8_3.9x4.9mm_P1.27mm,2,Si4162DY,
Q3,TSOT-23_HandSoldering,1,AO3400A,
"R1, R2, R23, R8",0603,4,4.7kR,
"R10, R11, R12",2512,3,15mR,
"R13, R14, R9",0603,3,680R,
"R15, R16",0603,2,2.7kR,
R17,0603,1,820,
"R18, R4",0603,2,5.6kR,
R19,0603,1,5.6kR,
R20,0603,1,3.3kR,
R21,0603,1,3.6kR,
"R22, R24, R26, R3, R6, R7",0603,6,10kR,
R25,0603,1,120R,
R27,0603,1,10k,
R5,0603,1,3.3kR,
TH1,PinHeader_1x02_P2.00mm_Vertical,1,Thermistor_NTC,
U1,XIAO-RP2040-SMD,1,XIAO-RP2040-DIP,
U11,StrawberryLinux_LTC3119,1,LTC3119,
U2,TSSOP-20_4.4x6.5mm_P0.65mm,1,MCP2515-xST,
"U3, U4, U6",VSSOP-10_3x3mm_P0.5mm,3,INA228,
U5,MSOP-16_3x4.039mm_P0.5mm,1,LTC4353,
U8,SOIC-8_3.9x4.9mm_P1.27mm,1,MCP2562-E-SN,
U9,SOT-23_Handsoldering,1,MCP1792x-5002xCB,
Y1,Crystal_HC49-4H_Vertical,1,8MHz,

## KiCad design KiCAD/SensingModule/SensingModule.kicad_pcb

Parts:
D1, D2: Blue; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
H5, H6, H7, H8: MountingHole_Pad; MountingHole_3.2mm_M3_DIN965_Pad_TopBottom
J1: DF11-8DP-2DS
J2: MONITOR; DF11-8DP-2DS; not fitted
R1, R2: 680R; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R7, R8, R9, R17: 4.7kR; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: ARDUINO_MKR_WAN_1310; BOARD_ARDUINO_MKR_WAN_1310; PARTREV 06/27/2019

Connections:
+3.3V: J2.1, R5.2, R6.2, R7.2, R8.2, R17.2, U1.J5_12 (+3V3); also elsewhere on the board
+3.3VP: R9.2; also elsewhere on the board
+5V: U1.J5_13 (VIN); also elsewhere on the board
+12V: J1.1, J1.2; also elsewhere on the board
CAN_H: J1.7, J1.8; also elsewhere on the board
CAN_L: J1.5, J1.6; also elsewhere on the board
CAN_RECEIVE_STATUS: U1.J3_9 (PA22/D0(PWM)); also elsewhere on the board
CAN_SEND_STATUS: U1.J3_10 (PA23/D1(PWM)); also elsewhere on the board
GND: D1.1 (K), D2.1 (K), J1.3, J1.4, J2.2, U1.J5_11 (GND); also elsewhere on the board
I2C_SCL: J2.4, R8.1, U1.J5_7 (PA09/D12(PWM)/SCL(SC2)); also elsewhere on the board
I2C_SDA: J2.3, R7.1, U1.J5_6 (PA08/D11/SDA(SC2)); also elsewhere on the board
LORA_RECEIVE_STATUS: R1.1, U1.J3_13 (PB10/D4(PWM))
LORA_SEND_STATUS: R2.1, U1.J3_14 (PB11/D5(PWM))
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
SPI_CS_MCP: R9.1, U1.J5_2 (PA21/D7(PWM)); also elsewhere on the board
SPI_MISO: U1.J5_5 (PA19/D10(PWM)/CIPO(SC1)); also elsewhere on the board
SPI_MOSI: U1.J5_3 (PA16/D8(PWM)/COPI(SC1)); also elsewhere on the board
SPI_SCLK: U1.J5_4 (PA17/D9/SCK(SC1)); also elsewhere on the board
SPI_~CS_FeRAM0: R6.1, U1.J5_9 (PB22/D14/TX(SC5)); also elsewhere on the board
SPI_~CS_FeRAM1: R5.1, U1.J3_4 (PB03/D17/AIN(11)/A2); also elsewhere on the board
SPI_~CS_FeRAM2: R17.1, U1.J5_8 (PB23/D13/RX(SC5)); also elsewhere on the board
VREF_T1: J2.5, U1.J3_5 (PA04/D18(PWM)/AIN(4)/A3)
VREF_T2: J2.6, U1.J3_6 (PA05/D19(PWM)/AIN(5)/A4)
VREF_T3: J2.7, U1.J3_7 (PA06/D20/AIN(6)/A5)
VREF_T4: J2.8, U1.J3_8 (PA07/D21/AIN(7)/A6)
VREF_THERMISTOR: U1.J3_2 (PA02/D15/DAC0/AIN(0)/A0); also elsewhere on the board

Notes on the sheet:
LoRa Status
M3 MoutHole
